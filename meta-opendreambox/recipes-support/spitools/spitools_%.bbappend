SRC_URI_remove = "git://github.com/cpb-/spi-tools.git;protocol=git"
SRC_URI += "git://github.com/cpb-/spi-tools.git;protocol=https"
