SRC_URI_remove = "git://github.com/troglobit/smcroute.git;branch=master;protocol=git"
SRC_URI += "git://github.com/troglobit/smcroute.git;branch=master;protocol=https"
