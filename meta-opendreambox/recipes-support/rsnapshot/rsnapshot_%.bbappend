SRC_URI_remove = "git://github.com/DrHyde/${BPN};branch=master;protocol=git"
SRC_URI += "git://github.com/DrHyde/${BPN};branch=master;protocol=https"
