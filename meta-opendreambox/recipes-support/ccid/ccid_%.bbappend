SRC_URI_remove = "https://alioth.debian.org/frs/download.php/file/4132/ccid-${PV}.tar.bz2"
SRC_URI = "https://alioth-archive.debian.org/releases/pcsclite/ccid/${PV}/ccid-${PV}.tar.bz2"
