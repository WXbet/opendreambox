SRC_URI_remove = "git://git.sv.gnu.org/gnulib;protocol=git"
SRC_URI += "git://git.sv.gnu.org/gnulib;protocol=https"
