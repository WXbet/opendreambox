SRC_URI_remove = "git://anongit.freedesktop.org/evtest;protocol=git"
SRC_URI += "git://anongit.freedesktop.org/evtest;protocol=https"
