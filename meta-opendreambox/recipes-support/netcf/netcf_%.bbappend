SRC_URI_remove = "git://git.fedorahosted.org/netcf.git;protocol=git"
SRC_URI += "git://git.fedorahosted.org/netcf.git;protocol=https"
