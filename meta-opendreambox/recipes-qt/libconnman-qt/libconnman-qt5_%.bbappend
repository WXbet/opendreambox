SRC_URI = "git://github.com/sailfishos/libconnman-qt.git;protocol=https;branch=master"
