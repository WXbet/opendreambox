RDEPENDS_${PN} = "apt apt-opkg dpkg apt-transport-https"

require packagegroup-pkg.inc

PKGTYPE = "deb"
