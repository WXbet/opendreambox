RDEPENDS_${PN}_remove = "nativesdk-shadow"
