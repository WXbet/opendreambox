SRC_URI_remove = "git://www.aleph1.co.uk/yaffs2;protocol=git;branch=master"
SRC_URI += "git://www.aleph1.co.uk/yaffs2;protocol=https;branch=master"
