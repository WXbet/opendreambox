SRC_URI_remove = "git://git.code.sf.net/p/libdc1394/code;branch=master;protocol=git"
SRC_URI += "git://git.code.sf.net/p/libdc1394/code;branch=master;protocol=https"
