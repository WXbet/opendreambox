FILESEXTRAPATHS_prepend := "${THISDIR}/${BPN}:"

SRC_URI += " \
    file://0001-lower-rank-for-broken-aac-dec.patch \
"
