SRC_URI_remove = "git://git.gnome.org/cantarell-fonts;protocol=git;branch=master"
SRC_URI += "git://git.gnome.org/cantarell-fonts;protocol=https;branch=master"
