SRC_URI_remove = "git://git.code.sf.net/p/aufs/aufs-util;protocol=git;branch=aufs3.14"
SRC_URI += "git://git.code.sf.net/p/aufs/aufs-util;protocol=https;branch=aufs3.14"
