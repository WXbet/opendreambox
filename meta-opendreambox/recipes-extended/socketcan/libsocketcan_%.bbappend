SRC_URI_remove = "git://git.pengutronix.de/git/tools/libsocketcan.git;protocol=git"
SRC_URI += "git://git.pengutronix.de/git/tools/libsocketcan.git;protocol=https"
