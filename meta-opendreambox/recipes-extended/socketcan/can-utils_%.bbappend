SRC_URI_remove = "git://github.com/linux-can/${BPN}.git;protocol=git;branch=master"
SRC_URI += "git://github.com/linux-can/${BPN}.git;protocol=https;branch=master"
