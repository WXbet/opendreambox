SRC_URI += "file://backport_perl.patch"

FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"
