SRC_URI_remove = "git://git.linaro.org/power/pm-qa.git;protocol=git;branch=${BRANCH}"
SRC_URI += "git://git.linaro.org/power/pm-qa.git;protocol=https;branch=${BRANCH}"
