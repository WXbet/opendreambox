IMAGE_PKGTYPE = "deb"

require dreambox-image.inc
require dreambox-image-signing.inc
