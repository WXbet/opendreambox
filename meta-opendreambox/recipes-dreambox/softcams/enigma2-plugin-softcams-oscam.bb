require oscam-latest.inc
require oscam.inc
require oscam-ipv6.inc
