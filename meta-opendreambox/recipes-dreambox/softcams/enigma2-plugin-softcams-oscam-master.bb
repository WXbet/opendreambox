require oscam-master-latest.inc
require oscam-master.inc
require oscam-ipv6.inc
